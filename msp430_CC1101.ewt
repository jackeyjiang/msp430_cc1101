<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>bsp</name>
    <file>
      <name>$PROJ_DIR$\bsp\bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\bsp\bsp.h</name>
    </file>
  </group>
  <group>
    <name>CC1101</name>
    <file>
      <name>$PROJ_DIR$\cc1101\CC1100.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\cc1101\CC1100.h</name>
    </file>
  </group>
  <group>
    <name>GRACE</name>
    <file>
      <name>$PROJ_DIR$\grace\BCSplus_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\grace\CSL_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\grace\GPIO_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\grace\grace.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\grace\Grace_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\grace\InterruptVectors_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\grace\System_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\grace\Timer0_A3_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\grace\WDTplus_init.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\MSP430PORT_DEF.h</name>
  </file>
</project>


