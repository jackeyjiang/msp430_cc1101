<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\msp430_CC1101.ewp</path>
  </project>
  <batchBuild/>
</workspace>


