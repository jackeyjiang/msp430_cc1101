# IAR project msp430_CC1101.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430g2553.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c main.h MSP430PORT_DEF.h
  group bsp
    bsp/: bsp.c bsp.h
  group CC1101
    cc1101/: CC1100.c CC1100.h
  group GRACE
    grace/: BCSplus_init.c CSL_init.c GPIO_init.c grace.h Grace_init.c InterruptVectors_init.c System_init.c Timer0_A3_init.c Timer1_A3_init.c WDTplus_init.c
